Commit message: .

File: config/urdf/modelc.urdf (robot description, URDF)
Before this commit: robot whill_simulator, 9 links, 8 joints
Links:
- removed link imu
- added link imu_whill
Joints:
- joint imu_joint: child imu -> imu_whill
